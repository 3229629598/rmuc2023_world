Commit message: 20230716

File: rmuc2023/urdf/rmuc2023.urdf (robot description, URDF)
Before this commit: robot rmuc2023, 1 links, 0 joints
Links:
- link base_link: mass 260478.340215205 -> 238258.08982698
